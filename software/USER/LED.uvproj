# Keil uVision project LED.uvproj, settings and files
target LED (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: LED +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\TOUCH;..\SYSTEM\sys;..\SYSTEM\DEALY;..\SYSTEM\UART;..\HARDWARE\SDCARD;..\Middlewares\FATFS;..\Middlewares\FreeRTOS\Source\include;..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\HARDWARE\VS1053
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../HARDWARE/SDCARD/: sdio_sdcard.c
    ../HARDWARE/VS1053/: spi.c vs1053.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_spi.c
    ../CORE/: startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/DEALY/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/UART/: uart.c
  group Middles/FATFS
    ../Middlewares/FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group Middles/FreeRTOS/CORE
    ../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middles/FreeRTOS/Porting
    ../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
